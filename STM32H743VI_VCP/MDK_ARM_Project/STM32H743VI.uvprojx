# Keil uVision project STM32H743VI.uvprojx, settings and files
target BASE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743VI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,CORE_CM7
  c include: ..\application;..\board\cmsis;..\board\device;..\board\driver;..\board\protocol;..\board\STM32H7xx_HAL_Driver\Inc;..\board\STM32H7xx_HAL_Driver\Inc\Legacy;..\logic;..\user;..\board\USB\USB_CORE;..\board\USB\USB_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group user
    ../user/: main.c
  group application
    ../application/: task.c
  group logic
    ../logic/: stm32h7xx_it.c cmd_process.c
  group board/cmsis
    ../board/cmsis/: system_stm32h7xx.c
  group board/device
    ../board/device/: Key.c LED.c
  group board/driver
    ../board/driver/: backupregist.c flash.c GPIO_BSP.c hal_sys.c iic_master.c stm32h7xx_hal_msp.c tim.c usart.c stm32h7xx_hal_conf.h adc.c
  group board/protocol
    ../board/protocol/: message_queue.c xmodem.c
  group board/STM32H7xx_HAL_Driver
    ../board/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_usb.c
  group board/startup
    ../board/startup/: startup_stm32h743xx.s
  group board/USB_CORE
    ../board/USB/USB_CORE/: usbd_cdc.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group board/USB_APP
    ../board/USB/USB_APP/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
